# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: E:\keil5_MDKorC51\C51\INC\Atmel
  group Source Group 1
    ./: main.c Delay.h Delay.c Nixie_Tube.c Nixie_Tube.h
