# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: E:\keil5_MDKorC51\C51\INC\Atmel
  group Source Group 1
    ./: main.c delay.c delay.h
    $TC_ROOT$/INC/Atmel/: 89c51rd2.h at8xc51snd1.h at8xc51snd2.h AT8xC5103.h at8xC5122.h at8xc5132.h at83C5123.h AT87F51RC.H at89c51cc03.h at89c51ic2.h at89c51RB2.h at89c51RC2.h at89c51xd2.h at89c5114.h at89c5131.h AT89LP52.H AT89LP213.H AT89LP214.H AT89LP216.H AT89LP428.H AT89LP828.H AT89LP2052.H AT89LP4052.H AT89LP6440.H AT89S4D12.H AT89S53.H AT89x051.H AT89X51.H AT89X52.H AT89X55.H AT891051.H AT892051.H AT898252.H ext_5131.h REG51.H REG51AC2.h REG51ATLPRB2.H REG51CC01.H REG51CC02.h REG51CC03.h REG51FP1.h REG51IC2.h REG51Ix2.h REG51RB2.h REG51RC2.h REG51RD2.h REG51U2.H REG51xD2.h REG52x2.h REG1051.H REG2051.H REG5101.h REG5103.h REG5111.h REG5112.h REG5114.h REG5121.h REG5122.h REG5123.h REG5131.h REG5132.h REG8252.H REG8253.H REGF51RC.H REGS4D12.H REGS53.H REGSND1.h REGx051.H REGX51.H REGX52.H REGX55.H t8xc5121.h T87C5111.h T87C5112.h t89c51ac2.h t89c51cc01.h t89c51cc02.h t89c51ix2.h t89c51rd2.h t89c51Rx2.h t89c5115.h
