# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: E:\keil5_MDKorC51\C51\INC\Atmel
  group Source Group 1
    ./: mian.c Delay.c Delay.h Timer0.c Timer0.h Timer_key.c Timer_key.h I2C.h AT24C02.h AT24C02.c I2C.c beep.c beep.h public.c public.h
